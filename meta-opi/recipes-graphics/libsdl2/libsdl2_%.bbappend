PACKAGECONFIG_APPEND = " gles2"
