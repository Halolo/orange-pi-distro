PACKAGECONFIG_append = " gbm"
