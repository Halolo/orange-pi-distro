DEPENDS_remove = "sunxi-mali"

DEPENDS += "mali-blobs"
