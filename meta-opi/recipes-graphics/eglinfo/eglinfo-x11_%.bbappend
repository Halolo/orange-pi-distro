RDEPENDS_${PN} += "mali-blobs"
