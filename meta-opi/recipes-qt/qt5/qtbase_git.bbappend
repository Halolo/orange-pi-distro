RDEPENDS_${PN} += "mali-blobs"

PACKAGECONFIG += "gles2 eglfs"
