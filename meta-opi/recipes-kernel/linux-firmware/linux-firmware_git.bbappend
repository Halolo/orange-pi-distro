PACKAGES =+ "${PN}-rtl8189es"

FILES_${PN}-rtl8189es = " \
	/lib/firmware/rtlwifi/rtl8192cfw.bin \
	/lib/firmware/rtlwifi/rtl8192cfwU.bin \
	/lib/firmware/rtlwifi/rtl8192cfwU_B.bin \
	/lib/firmware/rtlwifi/rtl8192cufw.bin \
	/lib/firmware/rtlwifi/rtl8192defw.bin \
	/lib/firmware/rtlwifi/rtl8192sefw.bin \
	/lib/firmware/rtlwifi/rtl8188efw.bin \
	/lib/firmware/rtlwifi/rtl8188eufw.bin \
	/lib/firmware/rtlwifi/rtl8192cufw_A.bin \
	/lib/firmware/rtlwifi/rtl8192cufw_B.bin \
	/lib/firmware/rtlwifi/rtl8192cufw_TMSC.bin \
    "
