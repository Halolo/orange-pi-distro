FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://Add_Spi_Nor_Flash_Boot_Support.patch"
